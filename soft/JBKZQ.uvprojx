# Keil uVision project JBKZQ.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: JBKZQ +hex
  AfterMake: fromelf.exe --bin --output  .\Objects\JB.BIN  .\Objects\JBKZQ.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER ,STM32F10X_HD
  c misc: --C99
  c include: .\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\USBCDC\inc;.\User\inc;.\Libraries\STM32_USB-FS-Device_Driver\inc;.\LCD_Driver;.\FLASH;.\GPRS;.\LOOP\inc;.\VOICE;.\GPIO_CTRL;.\RTC;.\Emwin\Config;.\Emwin\inc;.\UI;.\EVENT;.\CAN;.\DEVICE;.\Emwin\emWinTask;.\Emwin\inc;.\DEVICE;.\cm_backtrace
  memory RVCT4: ROM 0x8000000 size 0x7f000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./User/src/: delay.c main.c stm32f10x_it.c usbtask.c DIALOG_SliderColor.c
  group STM32_LIB
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group MDK_STARTUP
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group USB_FSLIB
    ./Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USBCDC
    ./USBCDC/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group LCD_Driverr
    ./LCD_Driver/: commenu.c lcddrv.c
  group Emwin
    ./Emwin/Config/: GUIConf.c LCDConf_FlexColor_Template.c
    ./Emwin/Lib/: STemWin522_CM3_Keil.lib
    ./Emwin/OS/: GUI_X.c
  group FLASH
    ./FLASH/: norflash.c sflash_spi.c
  group EVENT
    ./EVENT/: event.c shieldtask.c
  group GPRS
    ./GPRS/: gprs.c
  group VOICE
    ./VOICE/: voice.c
  group GPIO_CTRL
    ./GPIO_CTRL/: gpioctrl.c
  group LOOP
    ./LOOP/src/: init.c loop.c loop_hw.c LoopAnsOpt.c LoopDevTables.c LoopSendOpt.c stm32_flash.c
  group RTC
    ./RTC/: rt.c
  group UI
    ./UI/: UI_APP.c W1_MainWindow.c W2_MainWindows1.c W3_MenuWindows.c W4_FaultWindowPublic.c W5_FireWindowPublic.c W6_ShiledWindowPublic.c W7_SelfCheckWindowPublic.c W8_SetWindowPublic.c W9_SetTimeWindowPublic.c W10_EditDeviceWindowPublic.c W11_SetPhoneWindowPublic.c W12_ShieldSetWindowPublic.c W13_ReSetWindowPublic.c W14_FireQueryWindowPublic.c W15_FaultQueryWindowPublic.c W16_ShieldQueryWindowPublic.c W17_EventQueryWindowPublic.c W18_QueryWindowPublic.c W19_DeviceLightWindowPublic.c W20_LightSetWindowPublic.c W21_PhoneWindowPublic.c W22_LoopLoginWindowPublic .c W23_InfoWindowPublic.c W24_ CommunicationWindowPublic.c W25_ DeviceSetWindowPublic.c W26_ PasswordWindowPublic.c W25_DeviceSet.c
  group CAN
    ./CAN/: can.c
  group DEVICE
    ./DEVICE/: device.c
  group HanZi
    ./Emwin/HanZi/: GUI_Font16.c GUI_UC_EncodeNone.c GUICharPEx.c GUI_Font24.c
